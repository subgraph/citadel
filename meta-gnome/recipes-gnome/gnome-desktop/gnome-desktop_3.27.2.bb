require gnome-desktop.inc
SRC_URI[archive.md5sum] = "12d49a3f4f281078eeb1a9f07804ff35"
SRC_URI[archive.sha256sum] = "0b9c5c238a011fac746df2db8a9f081d4509d0e8c5c55c044ad0f674dab83aaf"

