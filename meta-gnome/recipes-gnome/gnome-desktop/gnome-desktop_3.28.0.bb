require gnome-desktop.inc
SRC_URI[archive.md5sum] = "3e7b67578307220a21688f28307b6789"
SRC_URI[archive.sha256sum] = "f1df71c39e32147f6d58f53a9c05b964b00b7c98fbca090419355437c72fd59d"


