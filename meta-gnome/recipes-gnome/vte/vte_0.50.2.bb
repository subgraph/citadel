require vte.inc
SRC_URI[archive.md5sum] = "1912cfd1d9cdd30cebeb908507acadc5"
SRC_URI[archive.sha256sum] = "79dd316bfaff48f2fb74d066baae0d830e1f44436796fe410a57297e5c5f09cf"
