require vte.inc
EXTRA_OECONF = "--with-gnutls"
SRC_URI[archive.md5sum] = "95b0d12864f7374128da33998e756e75"
SRC_URI[archive.sha256sum] = "d5ae72dddd57af493afa10ca2a290f284e588021b0bd8aaaa63dbb75de7c0567"
