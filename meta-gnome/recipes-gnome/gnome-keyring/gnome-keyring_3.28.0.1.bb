require gnome-keyring.inc
SRC_URI[archive.md5sum] = "e78cb39f006022a50ccfce1e0806c34e"
SRC_URI[archive.sha256sum] = "d17c996f0917d9fb9d86492d8ff6e834fe76e3231ec355f7016b29d2f960bd63"

