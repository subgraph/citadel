require gnome-keyring.inc
SRC_URI[archive.md5sum] = "9b4b2c59dc1db3a1309cbe1fa1f2c2e7"
SRC_URI[archive.sha256sum] = "97964e723f454be509c956ed5e38b5c2fd7363f43bd3f153b94a4a63eb888c8c"
