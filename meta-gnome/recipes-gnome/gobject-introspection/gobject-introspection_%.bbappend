PACKAGES =+ "libgirepository"
FILES_libgirepository = "\
    ${libdir}/libgirepository-1.0${SOLIBS} \
    ${libdir}/girepository-1.0 \
"
