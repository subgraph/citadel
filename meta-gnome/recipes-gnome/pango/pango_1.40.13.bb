require pango.inc
SRC_URI[archive.md5sum] = "6676d2110ed9f89b9b3cfbbd10d5b302"
SRC_URI[archive.sha256sum] = "f84e98db1078772ff4935b40a1629ff82ef0dfdd08d2cbcc0130c8c437857196"
