require pango.inc
SRC_URI[archive.md5sum] = "10fd7ddf2c7cbdf942087d16c0936669"
SRC_URI[archive.sha256sum] = "9924d88a3dcedff753f0763814a1605307c5c9c931413b8b47ea7267d1b19446"
