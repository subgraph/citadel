require gsettings-desktop-schemas.inc
SRC_URI[archive.md5sum] = "370610e29b37d063ede3ef0f29c06eb9"
SRC_URI[archive.sha256sum] = "4cb4cd7790b77e5542ec75275237613ad22f3a1f2f41903a298cf6cc996a9167"

