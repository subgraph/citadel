require gsettings-desktop-schemas.inc
SRC_URI[archive.md5sum] = "796b6ac1eff450261edd521b72e7fe6d"
SRC_URI[archive.sha256sum] = "76a3fa309f9de6074d66848987214f0b128124ba7184c958c15ac78a8ac7eea7"
