require gnome-settings-daemon.inc
SRC_URI[md5sum] = "77f335b7330573595e6349095c8d3630"
SRC_URI[sha256sum] = "5a3d156b35e03fa3c28fddd0321f6726082a711973dee2af686370faae2e75e4"
