require zenity.inc
SRC_URI[archive.md5sum] = "0916c428ed858242c0864da4dc4c7f02"
SRC_URI[archive.sha256sum] = "5e588f12b987db30139b0283d39d19b0fd47cab87840cc112dfe61e592826df8"
