require network-manager-applet.inc
SRC_URI[archive.md5sum] = "d796b3d8b0ee940e89b5572869e5379c"                                       
SRC_URI[archive.sha256sum] = "105010d3e37d00ff8fd1d69e294d3a51b45e2488bd2d27f5cfd3a372e5bee329"  
