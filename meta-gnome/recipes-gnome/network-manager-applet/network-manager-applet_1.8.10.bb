require network-manager-applet.inc
SRC_URI[archive.md5sum] = "eae3be75e77ff1a7ea3174be25e62d03"
SRC_URI[archive.sha256sum] = "0adc4bfae8b49f7a1d929c22ef20933bd41fb4a8b458280f44c65f9e45b4c9c3"
