require gnome-terminal.inc
SRC_URI[archive.md5sum] = "fcf3ea825bf8fc8f5d4db67e47c77ffe"
SRC_URI[archive.sha256sum] = "f24c7e061248989e5b0f0406a93a506059d52c23ed8e54eb6a33cd5a3da5214e"

