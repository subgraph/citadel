require gnome-terminal.inc
SRC_URI[archive.md5sum] = "46827785f9de78329a1d894a6a957b83"
SRC_URI[archive.sha256sum] = "a551d5eee10f66560fc7c6bdff6f7358ce9c60b526d8ba68a82f2ab024a3bcc4"
EXTRA_OECONF = "--disable-search-provider --without-nautilus-extension"


