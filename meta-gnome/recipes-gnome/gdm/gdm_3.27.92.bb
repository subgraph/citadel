require gdm.inc
SRC_URI[archive.md5sum] = "f8b2156d9cfa9be2d95f34f2ef08c44d"
SRC_URI[archive.sha256sum] = "c1107f8c13df3e54a250d946361b0bcc690fd4f2b22abc39f3e0e26a750ad632"
