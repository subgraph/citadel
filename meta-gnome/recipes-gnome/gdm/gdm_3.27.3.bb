require gdm.inc
SRC_URI[archive.md5sum] = "f05b16eec5beb587afb15a2b6135151b"
SRC_URI[archive.sha256sum] = "1b750664636089da7940a55c73c09aa5ad5d716194b3eeff49d5f41bc9efdae2"
