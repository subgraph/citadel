require gjs.inc
SRC_URI[archive.md5sum] = "d08c1dc0388a0a6bb0975d400928589e"
SRC_URI[archive.sha256sum] = "2fad902cf7a7806454121c03918755c646fcfd6b08b52d488987db4e2d691ff3"
