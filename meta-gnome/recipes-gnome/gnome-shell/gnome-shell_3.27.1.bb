require gnome-shell.inc
SRC_URI[archive.md5sum] = "d8b8521bad4f93f377c89240ceee3f33"
SRC_URI[archive.sha256sum] = "1972d39d1bb1ab708da3534911ac1f89acf45801b7c2cdc9ff9515f4eae17cc6"
