require gnome-shell.inc
SRC_URI[archive.md5sum] = "a0bf48381d8f4f081055f73764618016"
SRC_URI[archive.sha256sum] = "c7dec00d3c2b26e16611aac99630e3d41842179e9ec30cc873233b56c080ba4e"
