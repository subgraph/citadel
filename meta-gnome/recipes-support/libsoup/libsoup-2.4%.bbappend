# rest requires libsoup-gnome-2.4
PACKAGECONFIG = "gnome"
