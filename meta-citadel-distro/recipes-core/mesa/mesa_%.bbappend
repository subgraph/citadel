PACKAGECONFIG_append = " gallium gallium-llvm"
GALLIUMDRIVERS_append = ",virgl"
