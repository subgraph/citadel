
VOLATILE_BINDS += "\
    /storage/home/root /home/root\
"
