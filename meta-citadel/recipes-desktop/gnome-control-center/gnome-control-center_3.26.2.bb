require gnome-control-center.inc
SRC_URI[archive.md5sum] = "4f19c72a6cfe1956cc2172caae5494c1"
SRC_URI[archive.sha256sum] = "07aed27d6317f2cad137daa6d94a37ad02c32b958dcd30c8f07d0319abfb04c5"
