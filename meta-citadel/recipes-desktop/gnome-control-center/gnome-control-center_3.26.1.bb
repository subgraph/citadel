require gnome-control-center.inc
SRC_URI[archive.md5sum] = "61a55cddc794f4020f93df1290792f0e"
SRC_URI[archive.sha256sum] = "5e5dbb0cd6b882d02662a94c15613f29be3b9152aa38847b17f8d5bea2cfc290"
