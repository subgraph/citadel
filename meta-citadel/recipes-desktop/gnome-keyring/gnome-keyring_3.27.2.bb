require gnome-keyring.inc
SRC_URI[archive.md5sum] = "698cd578ab2f0d3bcafdd201bad701ef"
SRC_URI[archive.sha256sum] = "78434975c917f2a413e5ee50624e0ff3f45bc84b8520ef5d5f35d719fd3e9289"
