require gtk.inc
SRC_URI[md5sum] = "eeeb8038fe0d386c7516fa46cd4fff6b"
SRC_URI[sha256sum] = "61eef0d320e541976e2dfe445729f12b5ade53050ee9de6184235cb60cd4b967"
