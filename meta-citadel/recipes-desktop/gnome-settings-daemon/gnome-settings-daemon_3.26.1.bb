require gnome-settings-daemon.inc
SRC_URI[archive.md5sum] = "c214fe5e6166481cfabf8450756c51fe"
SRC_URI[archive.sha256sum] = "711ac9bad06f6a4225f5eb2f4796474662f81f7077e16a4b7ee7ab974b65d893"
