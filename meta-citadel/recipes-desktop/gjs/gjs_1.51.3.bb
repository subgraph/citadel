require gjs.inc
SRC_URI[archive.md5sum] = "bdac030c93760105f119c543b4512341"
SRC_URI[archive.sha256sum] = "3a0c0eae273cebcb88876c8a2f0c30835ed58b71859ab2aa4640f8fe1d894ef8"
