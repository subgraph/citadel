require gnome-shell.inc
SRC_URI[archive.md5sum] = "eee354999984c143a3eb60da8cf27ddf"
SRC_URI[archive.sha256sum] = "38d98da06eb0118a0226623494b11765b3981414e804e270dc0cf03e37c708b9"
