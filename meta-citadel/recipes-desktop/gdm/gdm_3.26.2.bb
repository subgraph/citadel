require gdm.inc
SRC_URI[archive.md5sum] = "ac91dfc1bf727a48dd1f3b587e0d15ab"
SRC_URI[archive.sha256sum] = "4b400367477303177d32c00582656ea735f91e2f7e259e5cc6db6d0afaf8dbc3"
