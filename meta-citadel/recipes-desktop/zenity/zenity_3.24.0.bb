require zenity.inc
SRC_URI[archive.md5sum] = "c905318c3ca76172d53829ed2471ac53"
SRC_URI[archive.sha256sum] = "6ff0a026ec94e5bc1b30f78df91e54f4f82fd982f4c29b52fe5dacc886a9f7f7"
