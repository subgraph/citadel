require zenity.inc
SRC_URI[archive.md5sum] = "7c28ce3f953de31a7a5c6311a3c5d607"
SRC_URI[archive.sha256sum] = "6a7f34626dd62b751fe22bcdb32f3558f8a8fdddcc9406893dd264f0ac18e830"
