require vte.inc
SRC_URI[archive.md5sum] = "a6f8fec3787e3cb72b3b31a8be6751a4"      
SRC_URI[archive.sha256sum] = "cf1708e3e573160e1db107014b3ef70888fefe6b668373fed70e8d1cac45a8c2"
