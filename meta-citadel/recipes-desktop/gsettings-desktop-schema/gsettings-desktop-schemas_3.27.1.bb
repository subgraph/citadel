require gsettings-desktop-schemas.inc
SRC_URI[archive.md5sum] = "8c91d5a3f90a8bf6a8448f13dbfd18cc"
SRC_URI[archive.sha256sum] = "2ffb131cbec43eb5a15dae25259050adbf0fc4278119cea0091a96d87cf392e8"
