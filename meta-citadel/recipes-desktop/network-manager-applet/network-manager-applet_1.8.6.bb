require network-manager-applet.inc
SRC_URI[archive.md5sum] = "9fd564a430201d0a8ff34f5ab50fc609"
SRC_URI[archive.sha256sum] = "01749e2c27d84ac858f59bc923af50860156eb510e2b6cf7d4941f753bef9c30"
