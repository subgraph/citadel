PACKAGECONFIG_append = " gallium "
GALLIUMDRIVERS_append = ",virgl"
