PACKAGECONFIG_append = " user-session"
