
inherit packagegroup

RDEPENDS_${PN} = "\
    adapta-gtk-theme \
    paper-icon-theme \
    ttf-roboto \
"
