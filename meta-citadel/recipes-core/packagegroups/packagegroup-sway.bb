
inherit packagegroup

RDEPENDS_${PN} = "\
    sgmenu \
    sgstatus \
    wlc \
    sway \
    xcb-util-xrm \
    rofi \
"
