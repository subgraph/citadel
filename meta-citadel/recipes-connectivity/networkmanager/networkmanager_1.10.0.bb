require networkmanager.inc
SRC_URI[md5sum] = "c4308b83f77a7cb8c6e0e0ec1a30c89f"
SRC_URI[sha256sum] = "8abbd60cf0e56003a7b9428ceb50a58c80e02e045ac31c3399e9227a712e04de"

