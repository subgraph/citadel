EXTRA_OECMAKE += "-DCMAKE_BUILD_TYPE=MinSizeRel "
