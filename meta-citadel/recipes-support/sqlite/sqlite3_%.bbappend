# for tracker
EXTRA_OECONF_append_class-target = " --enable-fts5"
