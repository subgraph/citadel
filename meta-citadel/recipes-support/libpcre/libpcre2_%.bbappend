EXTRA_OECONF = "--enable-jit"
