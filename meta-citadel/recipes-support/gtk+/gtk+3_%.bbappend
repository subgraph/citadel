# Remove this dependency so it doesn't get dragged in with gtk.  These icons are in citadel-extra-image now
GTKBASE_RRECOMMENDS_remove = "adwaita-icon-theme-symbolic"
