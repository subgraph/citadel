
PACKAGECONFIG = "fs crypto parted mdraid"
