# citadel-image.bbclass pulls in cryptsetup-native --> libdevmapper-native --> libaio-native
BBCLASSEXTEND = "native"
