PACKAGECONFIG = "odirect"
PACKAGECONFIG_append_class-target = " udev"
