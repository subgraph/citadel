
inherit packagegroup

RDEPENDS_${PN} = "ttf-roboto"
