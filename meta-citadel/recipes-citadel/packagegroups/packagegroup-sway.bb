
inherit packagegroup

RDEPENDS_${PN} = "\
    sgmenu \
    sgstatus \
    wlroots \
    sway \
    xcb-util-xrm \
    rofi \
    grim \
    slurp \
    polkit-gnome \
"

